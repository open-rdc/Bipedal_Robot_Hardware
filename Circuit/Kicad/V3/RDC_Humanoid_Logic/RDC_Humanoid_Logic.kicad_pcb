# Repository open-rdc/Bipedal_Robot_Hardware

File README.md:

# Bipedal_Robot_Hardware

RDC_LAB ２足歩行ロボット開発リポジトリ（ハードウェア）

## Circuit
- RDC_Bipedal_Logic
  - Logic回路基板。コンピュータや通信周り
  - Kicad Version: 7
- RDC_Bipedal_Power_Relay_Switch
  - Power回路のリレーのスイッチと、非常停止ボタンの回路
  - Kicad Version: 7
- RDC_Bipedal_Power
  - Power回路図。基板はなく回路図のみ
  - Kicad Version: 9
- RDC_CAN_Chain
  - CANのデイジーチェーン用基板
  - Kicad Version: 9

## LICECNSE

### Hardware
- designer: [Sato Tomoki](https://github.com/tomoki057)

### Circuit
- V1
  - designer: [YusukeYamasaki](https://github.com/Yusuke-Yamasaki-555)
- V2
  - RDC_Bipedal_Logic
    - designer:
      - [Yuya Mochizuki](https://github.com/Mochizuki12)
      - [YusukeYamasaki](https://github.com/Yusuke-Yamasaki-555)
  - RDC_Bipedal_Power_Relay_Switch
    - designer: [YusukeYamasaki](https://github.com/Yusuke-Yamasaki-555)
  - RDC_Bipedal_Power
    - designer: [YusukeYamasaki](https://github.com/Yusuke-Yamasaki-555)
  - RDC_CAN_Chain
    - designer: [YusukeYamasaki](https://github.com/Yusuke-Yamasaki-555)

### maintainer
- [open-rdc/Teams/Humanoid_Development_Team](https://github.com/orgs/open-rdc/teams/humanoid_development_team)

### contributor
- [open-rdc/Teams/Humanoid_Development_Team](https://github.com/orgs/open-rdc/teams/humanoid_development_team)
- [Yuya Mochizuki](https://github.com/Mochizuki12)

## KiCad design Circuit/Kicad/V3/RDC_Humanoid_Logic/RDC_Humanoid_Logic.kicad_pcb

Parts:
C1: 100uF; CP_Radial_D6.3mm_P2.50mm
C2: 0.1uF; C_0603_1608Metric
D1: D_Schottky; D_SOD-123
D2, D3, D4: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: XT60; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2, J3: Conn_01x03; JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal
J4: Raspi_connect; PinHeader_2x20_P2.54mm_Vertical
J5: 74AHC1G04W5; SOT-23-5
Q1, Q2: Q_PMOS_GDS; TO-252-2
R1, R2, R7, R8, R12, R15: 10k; R_0603_1608Metric
R9: 4.7k; R_0603_1608Metric
R10, R11: 1k; R_0603_1608Metric
SW1, SW2, SW3: SW_SPDT; Toggle_switch
U4: TBD62083AFG; SOP-18_7.495x11.515mm_P1.27mm

Connections:
+5V: D3.2 (A); also elsewhere on the board
+12V: C2.1, D1.1 (K), J1.2, Q1.3 (S), R1.1, R15.1; also elsewhere on the board
/CAN_Trans1/CANH: J2.2; also elsewhere on the board
/CAN_Trans1/CANL: J2.3; also elsewhere on the board
/CAN_Trans2/CANH: J3.2; also elsewhere on the board
/CAN_Trans2/CANL: J3.3; also elsewhere on the board
/Logic_Power/EN_RasPi_Power: U4.11 (O8); also elsewhere on the board
/Logic_Power/EN_STM_Power: U4.12 (O7); also elsewhere on the board
EN_Power: U4.10 (COMMON); also elsewhere on the board
EN_STM: J4.7, J5.2
EN_STM_VCC: J4.1, J5.5
GND: C1.2, D1.2 (A), J1.1, J4.6, J4.9, J4.14, J4.20, J4.25, J4.30, J4.34, J4.39, J5.3, R1.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, SW1.3 (C), U4.9 (GND); also elsewhere on the board
GND1: J2.1, J3.1; also elsewhere on the board
Logic_Power: C1.1, D2.2 (A), Q2.3 (S), R12.1, SW2.2 (B), SW3.2 (B); also elsewhere on the board
unnamed: D2.1 (K), R9.1
unnamed: D3.1 (K), R10.1
unnamed: D4.1 (K), R11.1
unnamed: J5.4, R7.1, SW2.1 (A), U4.7 (I7)
unnamed: Q1.2 (D), Q2.2 (D)
unnamed: C2.2, Q1.1 (G), Q2.1 (G), R2.1, R15.2
unnamed: R2.2, SW1.2 (B)
unnamed: R8.1, SW3.1 (A), U4.8 (I8)
RasPi_Power: D4.2 (A), J4.2, J4.4; also elsewhere on the board

Notes on the sheet:
B接点
修正済み
3V3
STANDBY is Low -> normal mode STANDBY is High -> standby mode (wake up by RXD)

Parts:
C3, C9, C11: 10uF; C_0603_1608Metric
C4, C10: 1uF; C_0603_1608Metric
C5, C8: 10nF; C_0603_1608Metric
C6, C7: 0.1uF; C_0603_1608Metric
FB1, FB2, FB3, FB4, FB5: FerriteBead; L_0805_2012Metric
J6: CH213K; SOT-23-3
R3: 4.7k; R_0603_1608Metric
R4: 120; R_0603_1608Metric
U1: ISOW1044; SOIC-20W_7.5x12.8mm_P1.27mm

Connections:
+5V: J6.3; also elsewhere on the board
/CAN_Trans1/CANH: R4.1, U1.19 (CANH); also elsewhere on the board
/CAN_Trans1/CANL: R4.2, U1.18 (CANL); also elsewhere on the board
/CAN_Trans1/CAN_RX: U1.5 (RXD); also elsewhere on the board
/CAN_Trans1/CAN_TX: U1.3 (TXD); also elsewhere on the board
GND: C6.2, FB1.1, J6.1, U1.2 (IN), U1.4 (STB), U1.6 (GNDIO); also elsewhere on the board
GND1: C7.2, C9.2, FB5.2, U1.15 (GISOIN), U1.16 (GISOIN), U1.17 (GISOIN); also elsewhere on the board
unnamed: FB2.1, FB3.1, J6.2, R3.1
unnamed: R3.2, U1.8 (EN/FLT)
unnamed: C3.2, C4.2, C5.2, FB1.2, U1.10 (GND1)
unnamed: C8.2, C10.2, C11.2, FB5.1, U1.11 (GND2)
unnamed: C3.1, C4.1, C5.1, FB2.2, U1.9 (V_{DD})
unnamed: C6.1, FB3.2, U1.1 (V_{IO})
unnamed: C7.1, C9.1, FB4.2, U1.20 (V_{ISOIN})
unnamed: C8.1, C10.1, C11.1, FB4.1, U1.12 (V_{ISOOUT}), U1.13 (V_{SIN})

Parts of its further copies:
C12, C18, C20: 10uF; C_0603_1608Metric
C13, C19: 1uF; C_0603_1608Metric
C14, C17: 10nF; C_0603_1608Metric
C15, C16: 0.1uF; C_0603_1608Metric
FB6, FB7, FB8, FB9, FB10: FerriteBead; L_0805_2012Metric
J7: CH213K; SOT-23-3
R5: 4.7k; R_0603_1608Metric
R6: 120; R_0603_1608Metric
U2: ISOW1044; SOIC-20W_7.5x12.8mm_P1.27mm

Connections of its further copies:
+5V: J7.3; also elsewhere on the board
/CAN_Trans2/CANH: R6.1, U2.19 (CANH); also elsewhere on the board
/CAN_Trans2/CANL: R6.2, U2.18 (CANL); also elsewhere on the board
/CAN_Trans2/CAN_RX: U2.5 (RXD); also elsewhere on the board
/CAN_Trans2/CAN_TX: U2.3 (TXD); also elsewhere on the board
GND: C15.2, FB6.1, J7.1, U2.2 (IN), U2.4 (STB), U2.6 (GNDIO); also elsewhere on the board
GND1: C16.2, C18.2, FB10.2, U2.15 (GISOIN), U2.16 (GISOIN), U2.17 (GISOIN); also elsewhere on the board
unnamed: FB7.1, FB8.1, J7.2, R5.1
unnamed: R5.2, U2.8 (EN/FLT)
unnamed: C12.2, C13.2, C14.2, FB6.2, U2.10 (GND1)
unnamed: C17.2, C19.2, C20.2, FB10.1, U2.11 (GND2)
unnamed: C12.1, C13.1, C14.1, FB7.2, U2.9 (V_{DD})
unnamed: C15.1, FB8.2, U2.1 (V_{IO})
unnamed: C16.1, C18.1, FB9.2, U2.20 (V_{ISOIN})
unnamed: C17.1, C19.1, C20.1, FB9.1, U2.12 (V_{ISOOUT}), U2.13 (V_{SIN})

Notes on the sheet:
修正済み
Logic_GND
from/to_STM32
Power_GND

Parts:
R13, R14: 10k; R_0603_1608Metric
for_PG1: M78AR05-0.5; M78A
to_RPI1: AE-MYMGK00506ERSR-5V0
to_STM1: AE-MYMGK00506ERSR-5V0

Connections:
+5V: to_STM1.7 (VOUT), to_STM1.8 (VOUT), to_STM1.9 (VOUT); also elsewhere on the board
+12V: for_PG1.1 (+V_{in}); also elsewhere on the board
/Logic_Power/EN_RasPi_Power: to_RPI1.2 (CTRL); also elsewhere on the board
/Logic_Power/EN_STM_Power: to_STM1.2 (CTRL); also elsewhere on the board
/Logic_Power/RasPi_PG: R14.2, to_RPI1.1 (PG)
/Logic_Power/STM_PG: R13.2, to_STM1.1 (PG)
EN_Power: R13.1, R14.1, for_PG1.3 (+V_{out}); also elsewhere on the board
GND: for_PG1.2 (GND), to_RPI1.3 (GND), to_RPI1.4 (GND), to_RPI1.10 (GND), to_RPI1.11 (GND), to_RPI1.12 (GND), to_STM1.3 (GND), to_STM1.4 (GND), to_STM1.10 (GND), to_STM1.11 (GND), to_STM1.12 (GND); also elsewhere on the board
Logic_Power: to_RPI1.5 (VIN), to_RPI1.6 (VIN), to_STM1.5 (VIN), to_STM1.6 (VIN); also elsewhere on the board
RasPi_Power: to_RPI1.7 (VOUT), to_RPI1.8 (VOUT), to_RPI1.9 (VOUT); also elsewhere on the board

Parts:
U3: NUCLEO-H755ZI-Q_Zio; NUCLEO-STM32H755ZI-Q

Connections:
+5V: U3.106 (5V_EXT); also elsewhere on the board
/CAN_Trans1/CAN_RX: U3.48 (PB8); also elsewhere on the board
/CAN_Trans1/CAN_TX: U3.50 (PB9); also elsewhere on the board
/CAN_Trans2/CAN_RX: U3.60 (PB5); also elsewhere on the board
/CAN_Trans2/CAN_TX: U3.80 (PB6); also elsewhere on the board
GND: U3.11 (GND), U3.13 (GND), U3.28 (GND), U3.39 (GND), U3.54 (GND), U3.69 (AGND), U3.71 (GND), U3.83 (GND), U3.88 (GND), U3.93 (GND), U3.108 (GND), U3.119 (GND), U3.120 (GND), U3.122 (GND), U3.149 (GND), U3.160 (GND); also elsewhere on the board

Notes on the sheet:
修正済み

Board: 2 copper layers, 168.0 x 134.0 mm, 72 parts (0 on the bottom side), 45 nets.

## KiCad design Circuit/Kicad/V2/RDC_Humanoid_CAN_chain/RDC_Humanoid_CAN_chain.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: R_Root_CAN; JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal
J2: L_Root_CAN; JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal
J3: CAN_motor1; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
J4: CAN_motor2; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
J5: CAN_motor3; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
J6: CAN_motor6; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
J7: CAN_motor5; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
J8: CAN_motor4; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal

Connections:
/L_Root_CAN_H: J2.2, J6.2, J7.2, J8.2
/L_Root_CAN_L: J2.1, J6.1, J7.1, J8.1
/R_Root_CAN_H: J1.2, J3.2, J4.2, J5.2
/R_Root_CAN_L: J1.1, J3.1, J4.1, J5.1
GND: J1.3, J2.3

Board: 2 copper layers, 69.8 x 25.4 mm, 10 parts (0 on the bottom side), 5 nets.

## KiCad design Circuit/Kicad/V2/RDC_Humanoid_Power_Relay_Switch/RDC_Humanoid_Power_Relay_Switch.kicad_pcb

Parts:
D1: D; D_SOD-123
D2: D_Zener; D_SOD-323
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: XT60; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: XA; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
J3: XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Q1: TK7R4A10RL; TO-220-3_Vertical
R1: R_100; R_0603_1608Metric
R2: R_10k; R_0603_1608Metric

Connections:
+12V: D1.1 (K), J1.2, J2.2, J3.3
GND: J1.1, Q1.3 (S), R2.2
unnamed: D1.2 (A), D2.2 (A)
unnamed: D2.1 (K), J3.1, Q1.2 (D)
unnamed: J2.1, R1.1
unnamed: Q1.1 (G), R1.2, R2.1

Notes on the sheet:
抜けにくさ、誤接続防止
data_sheet: https://www.fa.omron.co.jp/data_pdf/cat/g9eh-1_cdha-030_1_2.pdf?id=3848 Document (Surge Killer): https://faq.fa.omron.co.jp/tech/s/article/faq02804
OMRON G9EH-1

Board: 2 copper layers, 41.0 x 34.0 mm, 12 parts (0 on the bottom side), 6 nets.

## Commit log

2025-01-17 Add files via upload
    first
2025-01-17 ファイル場所の移動。URDF作成のためのDir整理
2025-01-17 add readme
2025-01-18 stlファイルの単位がダメだったので修正
2025-01-18 原点を変えた。ただ座標系は変えられない。
2025-01-18 簡易モデル用のIPT＆STLを作成した。
2025-01-18 未検証のURDFを作成
2025-01-18 inertiaの追加とpathの修正
2025-01-19 add wr2wp link
2025-01-19 簡易モデル（CAD、URDF）を作成した（質量と慣性は不正確）
2025-01-22 脛と足を別パーツ化
2025-01-23 add circuit v1 diagram (部品選定はまだ)
2025-01-23 add v1-1
2025-01-27 全体の基本的な回路図の更新。Kicadでモータの電源周りのfootprintをテキトーに書いてみた。
2025-01-27 サージキラーが接点側についていたので、コイル側に修正
2025-01-30 circuit version1.2
2025-01-30 胴体を追加しました。(300*150*150mm)
2025-01-31 Create Logic-Circuit Ver. 1.2.1 & Add part symbols for KiCad.
2025-02-01 高圧DCDCのラインを引いた
2025-02-01 logicのsupply周りの回路のスケッチを書いた
2025-02-05 version1.2.1のLogic周りの回路図を書いた
2025-02-05 upd backup
2025-02-06 footprintを一部追加
2025-02-06 FBとチップセラミックコンデンサを選定し、footprintを作成。
2025-02-06 チップ抵抗のfootprintを追加
2025-02-06 脚部の設計を一部変更しました
2025-02-06 脚部部品を一部変更しました
2025-02-13 LogicのPCBを途中まで作った
2025-02-14 Add files via upload
    2/14時点で印刷可能なパーツ
2025-02-17 Create A_file
2025-02-17 パーツを追加しました
2025-02-18 追加です
2025-02-18 新しく追加しました。
2025-02-20 Create Hardware
2025-02-20 モックアップから少し変更しました
    Assembly9 が片足の設計
    Assembly9_overall が胴体を含めた設計になります
2025-02-20 BR_parts_01が抜けていたのであげなおしました。
2025-02-21 can_transceiver周りのPCBを作った（仮）
2025-02-24 can回路にLEDを追加。整理。
2025-02-27 スイッチの追加と整理。
2025-03-01 Version1のLogic基板が、形はできた。検査や見積もりはまだ
2025-03-06 コメントの箇所を修正
2025-03-06 シルクを直した
2025-03-06 v1-3ぐらい
2025-03-07 power側の回路図を作成。ヒューズ無しバージョン
2025-03-08 Logic回路Ver2の作成開始。アドバイスを元に、参考回路をほぼ丸々コピーして作成する予定
2025-03-09 制御回路V2を追加
2025-03-09 よくわからんV1の変化をコミット
2025-03-11 V2をUpdate。FrontをベタGND、CANトランシーバのSTANDBYとINをGNDに接続、ビアを複数配置、XT30->XT60に更新、D1を回路図通りショットキーバリアダイオードに変更した。
2025-03-11 リレーのスイッチング＆サージキラーの回路図を組んだ
2025-03-13 V2基板手直し
2025-03-14 ビアを増やした。おおよそV2は良いだろう
2025-03-16 部品表の作成、多少のFootPrint、PCBの変更
2025-03-20 gbrの生成
2025-03-20 Filter position control for Steadywin-GIM8108-8
2025-03-20 リレーコイルのスイッチ基板の回路図を起こした
2025-03-21 changed from keyboard to pygame
2025-03-22 Relay_Switchの回路図とPCBを組んでみた。
2025-03-25 アドバイスを元に修正。Relay Switch用の基板ができた。
2025-03-27 回路図のコメントの修正
2025-04-01 回路置き場のモデルを作成した。URDF未適用
2025-04-01 新しくモック作る用
2025-04-02 URDF用のfail
2025-04-03 Update Simple-Model-Mesh
2025-04-03 simple_modelに胴体を搭載。寸法・質量・慣性をUpdate。それっぽい感じになったのでよし。
2025-04-07 回路図をPDFに出力
2025-04-07 Power回路図を引いた
2025-04-15 CANのデイジーチェーン用基板を作成
2025-04-15 CANのデイジーチェーン用基板をUpdate
2025-04-16 足先と外装の発注ファイル
2025-04-16 power側の回路をUpdate
2025-04-21 足先とリンクの発注です
2025-04-21 20250421のあげなおし
2025-04-23 CAN_Chainにビア配置、テキスト整理。Gerberファイル出力
2025-04-29 Logic V3 開始
2025-05-07 20250507
2025-05-07 iptファイルとdwgファイルを追加しました
2025-05-14 5/13時点での胴体をあげました
2025-05-31 logic V3のトランジスタアレイ周りを修正
2025-07-04 修正箇所を修正した
2025-07-19 Update V3 logic. 回路図の更新完了。PCB途中
2025-07-22 配線途中
2025-07-29 Logic V.3の完了
2025-09-16 250916
2025-09-29 ガーバーファイル生成
2025-10-08 Add files via upload
    最新版の胴体を共有しました
2026-01-30 commitし忘れをadd
2026-02-20 Create Hardware
    設計データ保管
2026-02-20 Create Design Data
2026-02-20 Create file
2026-02-27 Create gitkeep
2026-02-27 add a file1
2026-02-27 add a file2
2026-02-27 add a file3
